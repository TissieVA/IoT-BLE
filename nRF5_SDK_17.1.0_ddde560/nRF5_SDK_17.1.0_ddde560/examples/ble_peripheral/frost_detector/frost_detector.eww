<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>  <project>
    <path>$WS_DIR$\pca10040\s112\iar\frost_detector_pca10040_s112.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10056\s140\iar\frost_detector_pca10056_s140.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10100\s140\iar\frost_detector_pca10100_s140.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10040\s132\iar\frost_detector_pca10040_s132.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10056\s113\iar\frost_detector_pca10056_s113.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10100\s113\iar\frost_detector_pca10100_s113.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10100e\s112\iar\frost_detector_pca10100_s112.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10100e\s140\iar\frost_detector_pca10100e_s140.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10056e\s112\iar\frost_detector_pca10056e_s112.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10040e\s112\iar\frost_detector_pca10040e_s112.ewp</path>
  </project>  <batchBuild/>
</workspace>